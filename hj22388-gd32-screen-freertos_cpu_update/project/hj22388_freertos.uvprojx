# Keil uVision project hj22388_freertos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hj22388_freertos-lcd +hex
  AfterMake: fromelf --bin -o ../temp/@L.bin ../output/Objects/@L.axf
  AfterMake: ../tools/combin ../temp/gd32f103-iap.bin ../temp/hj22388_freertos-lcd.bin ../output/hj22388_freertos-lcd.bin
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\bsp;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\libs;..\microshell
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: app.c cli_cmd.c gd32f10x_it.c main.c serial_frame.c ota-uart.c
  group libs
    ../libs/: ringbuffer.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group microshell
    ../microshell/: ansi.c ansi_port.c nr_micro_shell.c
  group bsp
    ../bsp/: bsp.c bsp_24cxx.c bsp_debug_uart.c bsp_i2c_gpio.c bsp_pwm.c bsp_comm_uart.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
